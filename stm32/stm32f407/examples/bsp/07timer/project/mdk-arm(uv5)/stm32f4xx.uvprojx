# Keil uVision project stm32f4xx.uvprojx, settings and files
target flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4xx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER,USE_FULL_LL_DEIVER
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\STM32F4xx\Include;..\..\libraries\STM32F4xx_HAL_Driver\Inc;..\..\libraries\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\src;..\..\src\common;..\..\src\dirvers;..\..\src\devices\device_switch_led;..\..\src\devices\device_key;..\..\src\devices\device_beep;..\..\src\components\soft_timer;..\..\src\dirvers\driver_uart;..\..\src\dirvers\driver_timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ../../src/: main.c
  group Devices
    ../../src/devices/device_switch_led/: device_switch_led.c
    ../../src/devices/device_key/: device_key.c
    ../../src/devices/device_beep/: device_beep.c
  group Drivers
    ../../src/dirvers/: base.c
    ../../src/dirvers/driver_uart/: driver_uart_fifo.c
    ../../src/dirvers/driver_timer/: driver_timer_base.c driver_timer.c driver_timer_it.c driver_pwm_out.c
  group Common
    ../../src/common/: comm_init.c
  group Components
    ../../src/components/soft_timer/: soft_timer.c
  group Libraries
    ../../libraries/STM32F4xx/Source/arm/: startup_stm32f407xx.s
    ../../libraries/STM32F4xx/Source/: system_stm32f4xx.c
    ../../libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c
    ../../../06uasrt/libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
