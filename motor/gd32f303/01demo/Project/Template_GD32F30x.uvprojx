# Keil uVision project Template_GD32F30x.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template_GD32F30x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_HD
  c include: ..\Libraries\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS\GD\GD32F30x\Include;..\Libraries\GD32F30x_Firmware_Library_V2.1.3\Firmware\CMSIS;..\Libraries\GD32F30x_Firmware_Library_V2.1.3\Firmware\GD32F30x_standard_peripheral\Include;..\Libraries\nr_micro_shell-master\inc;..\UserCode\App\inc;..\UserCode\Bsp\inc;..\UserCode\Comm\inc;..\UserCode\Device\inc;..\UserCode\Funcs\inc;..\UserCode\Test\inc;..\UserCode\Utils\inc;..\UserCode\Protocol\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../UserCode/App/src/: main.c
  group Bsp
    ../UserCode/Bsp/src/: bsp_init.c gd32f30x_it.c systick.c debug_usart.c bsp_adc.c bsp_timer.c bsp_encoder.c bsp_basic_timer.c
  group Funcs
    ../UserCode/Funcs/src/: func_init.c
  group Device
    ../UserCode/Device/src/: device_init.c device_motor.c
  group MDK_ARM
    ../Libraries/GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group CMSIS
    ../Libraries/GD32F30x_Firmware_Library_V2.1.3/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Driver
    ../Libraries/GD32F30x_Firmware_Library_V2.1.3/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Protocol
    ../UserCode/Protocol/src/: protocol.c
  group Utils
    ../UserCode/Utils/src/: utils_pid.c
